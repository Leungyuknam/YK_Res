# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8412 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/main/: mian.c
    ./c/Key/: key.c
    ./c/KeyFunction/: KeyFunction.c
    ./c/Peripheral/: peripheral.c
    ./c/SystemTime/: SystemTime.c
    ./lib/: S_TouchKeyCFG.C SC92F8X1XB_HighSensitive_lib_T1_S_V2.2.0.LIB
    ./c/Interrupt/: interrupt.c
    ./c/Buz/: BUZ.c
    ./c/SenseDeal/: SenseDeal.c
    ./c/Function/: Function.c
    ./c/Display/: Display.c
    ./c/SelfTestDeal/: SelfTestDeal.c
    ./c/AD/: AD.c
