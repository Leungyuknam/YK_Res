# Keil uVision project DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC95R503M28U SC95Rxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ./IAP_Lib/: SC95R503_IAP_L_lib_V1.4.0.LIB
    ./c/AD/: AD.c
    ./c/Buzzer/: Buzzer.c
    ./c/CH2O/: CH2O.c
    ./c/DCFanDrv/: DCFanDrv.C
    ./c/Display/: Display.c
    ./c/Eeprom/: Eeprom.c
    ./c/FuncQueue/: FuncQueue.c
    ./c/Function/: Function.c
    ./c/IAP_Init/: IAP_Init.c
    ./c/Interrupt/: interrupt.c
    ./c/Key/: key.c
    ./c/KeyFunction/: KeyFunction.c
    ./c/main/: mian.c
    ./c/Peripheral/: peripheral.c
    ./c/SelfTestDeal/: SelfTestDeal.c
    ./c/SenseDeal/: SenseDeal.c
    ./c/SystemTime/: SystemTime.c
    ./c/TransferDataDeal/: TransferDataDeal.c
    ./c/TuyaWifi/: TuyaWifi.c
    ./c/Uart_Duplex/: Uart_Duplex.c
    ./c/Uart_Duplex_WIfi/: Uart_Duplex_Wifi.c
    ./c/Uart_Duplex2/: Uart_Duplex2.c
    ./c/VOC/: VOC.c
    ./c/Voice/: Voice.c
    ./c/ZH07/: ZH07.c
    ./c/FuncQueueB/: FuncQueueB.c
