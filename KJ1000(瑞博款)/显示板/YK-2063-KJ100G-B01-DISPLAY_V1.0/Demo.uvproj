# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8463B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/main/: mian.c
    ./c/Key/: key.c
    ./c/Peripheral/: peripheral.c
    ./c/SenseDeal/: SenseDeal.c
    ./c/SystemTime/: SystemTime.c
    ./c/TransferDataDeal/: TransferDataDeal.c
    ./c/Uart_Duplex/: Uart_Duplex.c
    ./c/Uart0/: Uart0.c
    ./c/Display/: Display_Drive.C Display.c
    ./lib/: SC92F8X1XB_HighSensitive_lib_T1_L_V2.2.0.LIB S_TouchKeyCFG.C
    ./c/Interrupt/: interrupt.c
    ./c/Commucate/: Commucate.c
