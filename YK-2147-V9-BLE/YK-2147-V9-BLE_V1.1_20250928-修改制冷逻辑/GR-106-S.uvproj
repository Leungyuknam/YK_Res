# Keil uVision project GR-106-S.uvproj, settings and files
target GR-106-S (MCS-51)
  device: SC95F8522 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: YK-2147-JZ-BLE_SC95F8522_ +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;.\Thm_Module;.\User;.\FWLib\SC95F_Lib\inc
  link misc: REMOVEUNUSED
  group APP
    ./: STARTUP.A51
    ./Src/: main.c Init.c
    ./Thm_Module/System_Time/: SystemTime.c
    ./Thm_Module/DigitalLedDisplay/: DigitalLedDisplay.C
    ./Thm_Module/Buzzer/: Buzzer.c
    ./Thm_Module/Key/: Key.c KeyEvent.c
    ./Thm_Module/SelfCheck/: SelfCheck.C
    ./Thm_Module/ADC/: AdEvent.c ADC1.c
    ./Thm_Module/Memory/: Memory.C
    ./Thm_Module/Display/: Display.c
    ./Thm_Module/Celsius_Fahrenheit/: Celsius_Fahrenheit.c
    ./Thm_Module/CarRefrigerator/: CarRefrigerator.c
    ./Thm_Module/AnalogPwm/: AnalogPwm.C
    ./Thm_Module/Uart/: uart.c Uart_App.c
    ./Thm_Module/Uart1/: uart_1.c Uart_App_1.c
  group SINONE LIB
    ./FWLib/SC95F_Lib/src/: sc95f_iap.c
