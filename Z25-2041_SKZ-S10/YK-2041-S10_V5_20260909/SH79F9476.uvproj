# Keil uVision project SH79F9476.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH79F9463A Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0-0xFFF) CLOCK(24000000)
  output: SH79F9476 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/Main/: main.c
    ./c/SystemTime/: SystemTime.c
    ./c/Peripheral/: peripheral.c
    ./c/Interrupt/: interrupt.c
    ./c/Key/: key.c
    ./c/KeyFunction/: KeyFunction.c
    ./c/Display/: Display.c
    ./c/Function/: Function.c
    ./c/SenseDeal/: SenseDeal.c
    ./c/DCFanDrv/: DCFanDrv.C
    ./c/RGBDrv/: RGBDrv.c
    ./c/ZS13/: ZS13.c
    ./c/Buz/: BUZ.c
    ./c/TouchKey/: tk_328_v2p4_16key_L.LIB tk_cfg.c tk_debug.c
    ./c/DisplayDrive_TMS6644/: TMS6644.c
    ./c/TransferDataDeal/: TransferDataDeal.c
    ./c/IAP_Init/: IAP_Init.c
    ./c/Eeprom/: Eeprom.c
    ./c/SelfTestDeal/: SelfTestDeal.c
  group README
    ./c/: README.txt
  group OEM_WIFI_SDK
    ./OEM_WIFI_SDK/: CodeI2cDrv.C WifiCommDrv.C WifiCommHard.C WifiInterFace.C OTA-API-Trans-LIB-20260529.LIB firmware.a51
