# Keil uVision project SC92F8XAX_T1_Demo_Code.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7412 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: SC92F8XAX_T1_Demo_Code +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/: main.c
    ./MyLib/Common/: Common.c
    ./MyLib/McuInit/: McuInit.c
    ./MyLib/Interrupt/: Interrupt.c
    ./MyLib/Function/: Function.c
    ./MyLib/KeyEvent/: KeyEvent.c
    ./MyLib/Key/: Key.c
    ./MyLib/OutDeal/: OutDeal.c
    ./MyLib/DispDriveIO/: DispDriveIO.c
    ./MyLib/Display/: Display.c
    ./MyLib/beep/: beep.c
    ./MyLib/Uart_Duplex/: Uart_Duplex.c
    ./MyLib/Uart_DuplexCom/: Uart_DuplexCom.c
    ./MyLib/IrReceive/: IrReceive.c
    ./MyLib/TransferDataDeal/: TransferDataDeal.c
    ./MyLib/SenseDeal/: SenseDeal.c
    ./MyLib/DispMcu/: DispMcu.c
  group ReadMe
    ./ReadMe/: ReadMe.txt
