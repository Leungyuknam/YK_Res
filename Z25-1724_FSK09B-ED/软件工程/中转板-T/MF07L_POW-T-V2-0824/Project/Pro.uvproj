# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC88F0441 HC88F Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(32000000)
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: ..\..\1-ExampleProject
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
    ../MyLib/Common/: Common.c
    ../MyLib/Function/: Function.c
    ../MyLib/Interrupt/: Interrupt.c
    ../MyLib/McuInit/: McuInit.c
    ../MyLib/Uart_Duplex/: Uart_Duplex.c
    ../MyLib/Uart_DuplexCom/: Uart_DuplexCom.c
    ../MyLib/: AD.c
    ../MyLib/StepMotor/: StepMotor.c
    ../MyLib/RL_StepMotor/: RL_StepMotor.c
    ../MyLib/SenseDeal/: SenseDeal.c
